# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\User\enc28j60;..\User\Net;..\User\BSP;..\User\uIP-1.0\uip;..\User\uIP-APP;..\User\uIP-1.0\apps\webserver;..\User\ProfiBus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c usart.c function.c
  group StdPeriph_Driver
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c misc.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_dbgmcu.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_sdio.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group ENC28J60
    ../User/enc28j60/: ENC28J60.C SPI.C
  group BSP
    ../User/BSP/: GPIO_Init.c 74HC595.c delay.c timerx.c sys.c zigbee.c queue.c parser.c wdg.c
  group uIP-1.0
    ../User/uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP-APP
    ../User/uIP-APP/: clock-arch.c tapdev.c tcp_client_demo.c tcp_demo.c tcp_server_demo.c
